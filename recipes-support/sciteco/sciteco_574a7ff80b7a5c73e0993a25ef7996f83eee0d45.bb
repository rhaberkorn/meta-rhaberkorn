require sciteco.inc
