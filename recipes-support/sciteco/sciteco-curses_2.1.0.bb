require sciteco-curses.inc

# This is the default recipe for tagged releases
SRCREV = "v${PV}"
