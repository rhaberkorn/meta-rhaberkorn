require sciteco.inc

SRCREV = "v0.6.4"
